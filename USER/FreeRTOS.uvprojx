# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1, __CC_ARM,__TARGET_FPU_VFP
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\HARDWARE\TIMER;..\HARDWARE\24L01;..\HARDWARE\AS5048A;..\HARDWARE\CAN;..\HARDWARE\CHASSIS_CONTROL;..\HARDWARE\DMA_UART;..\HARDWARE\GPIO;..\HARDWARE\M3508_CONTROL;..\HARDWARE\MOTOR_CONTROL;..\HARDWARE\MOVE_BASE;..\HARDWARE\OPS9;..\HARDWARE\PID;..\HARDWARE\protocol;..\HARDWARE\SHOOT;..\HARDWARE\System_Init;..\HARDWARE\USER_MATH;..\HARDWARE\PATH
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/24L01/: 24L01.c
    ../HARDWARE/AS5048A/: AS5048A.c
    ../HARDWARE/CHASSIS_CONTROL/: chassis_control.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/DMA_UART/: bsp_dma_usart.c
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/M3508_CONTROL/: m3508_CONTROL.c
    ../HARDWARE/MOTOR_CONTROL/: motor_control.c
    ../HARDWARE/MOVE_BASE/: moveBase.c
    ../HARDWARE/OPS9/: ops9.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/protocol/: protocol.c
    ../HARDWARE/SHOOT/: shoot.c
    ../HARDWARE/System_Init/: System_Init.c
    ../HARDWARE/USER_MATH/: user_math.c
    ../HARDWARE/PATH/: path.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s arm_cortexM4lf_math.lib
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_fsmc.c stm32f4xx_dma.c stm32f4xx_can.c stm32f4xx_spi.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: readme.txt
